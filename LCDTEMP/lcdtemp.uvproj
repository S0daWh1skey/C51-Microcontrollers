# Keil uVision project lcdtemp.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: lcdtemp +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    E:/C51/LCDTEMP/: STARTUP.A51
    ./: main.c 1602.c delay.c 18b20.c
